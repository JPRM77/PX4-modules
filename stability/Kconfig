## stability/Kconfig
```kconfig
menuconfig EXAMPLES_STABILITY
        bool "Stability"
        default n
        ---help---
                Enable Stability module
```
